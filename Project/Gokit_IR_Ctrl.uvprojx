# Keil uVision project Gokit_IR_Ctrl.uvprojx, settings and files
target gokit_stm32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gokit_mcu_stm32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,MOTOR_16
  c misc: --c99
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Hal;..\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c delay.c
    ../Hal/hal_motor/: hal_motor.c
    ../Hal/Hal_rgb_led/: hal_rgb_led.c
    ../Hal/Hal_led/: Hal_led.c
  group Hal
    ../Hal/Hal_key/: hal_key.c
    ../Hal/Hal_led/: Hal_led.c
    ../Hal/Hal_Usart/: hal_uart.c
    ../Hal/Hal_PIR/: Hal_PIR.c Hal_PIR_Rec.c
    ../Hal/Hal_rgb_led/: hal_rgb_led.c
  group Protocol
    ../Protocol/: Protocol.c ringbuffer.c
software components: CMSIS:CORE 4.3.0
